#include <string.h>

#include "gfx.h"

static uint8_t fb[KIT_LCD_PAGES][GFX_W];		/* what the application drew */
static uint8_t shown[KIT_LCD_PAGES][GFX_W];		/* what the display holds */

/* classic 5x7 font, ASCII 0x20..0x7E, 5 columns per glyph, bit 0 = top row.
 * g j p q y reach into the 8th row (bit 7) with their descenders. */
static const uint8_t font5x7[95][5] = {
	{0x00,0x00,0x00,0x00,0x00}, {0x00,0x00,0x5F,0x00,0x00}, {0x00,0x07,0x00,0x07,0x00}, {0x14,0x7F,0x14,0x7F,0x14},
	{0x24,0x2A,0x7F,0x2A,0x12}, {0x23,0x13,0x08,0x64,0x62}, {0x36,0x49,0x55,0x22,0x50}, {0x00,0x05,0x03,0x00,0x00},
	{0x00,0x1C,0x22,0x41,0x00}, {0x00,0x41,0x22,0x1C,0x00}, {0x14,0x08,0x3E,0x08,0x14}, {0x08,0x08,0x3E,0x08,0x08},
	{0x00,0x50,0x30,0x00,0x00}, {0x08,0x08,0x08,0x08,0x08}, {0x00,0x60,0x60,0x00,0x00}, {0x20,0x10,0x08,0x04,0x02},
	{0x3E,0x51,0x49,0x45,0x3E}, {0x00,0x42,0x7F,0x40,0x00}, {0x42,0x61,0x51,0x49,0x46}, {0x21,0x41,0x45,0x4B,0x31},
	{0x18,0x14,0x12,0x7F,0x10}, {0x27,0x45,0x45,0x45,0x39}, {0x3C,0x4A,0x49,0x49,0x30}, {0x01,0x71,0x09,0x05,0x03},
	{0x36,0x49,0x49,0x49,0x36}, {0x06,0x49,0x49,0x29,0x1E}, {0x00,0x36,0x36,0x00,0x00}, {0x00,0x56,0x36,0x00,0x00},
	{0x08,0x14,0x22,0x41,0x00}, {0x14,0x14,0x14,0x14,0x14}, {0x00,0x41,0x22,0x14,0x08}, {0x02,0x01,0x51,0x09,0x06},
	{0x32,0x49,0x79,0x41,0x3E}, {0x7E,0x11,0x11,0x11,0x7E}, {0x7F,0x49,0x49,0x49,0x36}, {0x3E,0x41,0x41,0x41,0x22},
	{0x7F,0x41,0x41,0x22,0x1C}, {0x7F,0x49,0x49,0x49,0x41}, {0x7F,0x09,0x09,0x09,0x01}, {0x3E,0x41,0x49,0x49,0x7A},
	{0x7F,0x08,0x08,0x08,0x7F}, {0x00,0x41,0x7F,0x41,0x00}, {0x20,0x40,0x41,0x3F,0x01}, {0x7F,0x08,0x14,0x22,0x41},
	{0x7F,0x40,0x40,0x40,0x40}, {0x7F,0x02,0x0C,0x02,0x7F}, {0x7F,0x04,0x08,0x10,0x7F}, {0x3E,0x41,0x41,0x41,0x3E},
	{0x7F,0x09,0x09,0x09,0x06}, {0x3E,0x41,0x51,0x21,0x5E}, {0x7F,0x09,0x19,0x29,0x46}, {0x46,0x49,0x49,0x49,0x31},
	{0x01,0x01,0x7F,0x01,0x01}, {0x3F,0x40,0x40,0x40,0x3F}, {0x1F,0x20,0x40,0x20,0x1F}, {0x3F,0x40,0x38,0x40,0x3F},
	{0x63,0x14,0x08,0x14,0x63}, {0x07,0x08,0x70,0x08,0x07}, {0x61,0x51,0x49,0x45,0x43}, {0x00,0x7F,0x41,0x41,0x00},
	{0x02,0x04,0x08,0x10,0x20}, {0x00,0x41,0x41,0x7F,0x00}, {0x04,0x02,0x01,0x02,0x04}, {0x40,0x40,0x40,0x40,0x40},
	{0x00,0x01,0x02,0x04,0x00}, {0x20,0x54,0x54,0x54,0x78}, {0x7F,0x48,0x44,0x44,0x38}, {0x38,0x44,0x44,0x44,0x20},
	{0x38,0x44,0x44,0x48,0x7F}, {0x38,0x54,0x54,0x54,0x18}, {0x08,0x7E,0x09,0x01,0x02}, {0x18,0xA4,0xA4,0xA4,0x7C},
	{0x7F,0x08,0x04,0x04,0x78}, {0x00,0x44,0x7D,0x40,0x00}, {0x40,0x80,0x84,0x7D,0x00}, {0x7F,0x10,0x28,0x44,0x00},
	{0x00,0x41,0x7F,0x40,0x00}, {0x7C,0x04,0x18,0x04,0x78}, {0x7C,0x08,0x04,0x04,0x78}, {0x38,0x44,0x44,0x44,0x38},
	{0xFC,0x24,0x24,0x24,0x18}, {0x18,0x24,0x24,0x28,0xFC}, {0x7C,0x08,0x04,0x04,0x08}, {0x48,0x54,0x54,0x54,0x20},
	{0x04,0x3F,0x44,0x40,0x20}, {0x3C,0x40,0x40,0x20,0x7C}, {0x1C,0x20,0x40,0x20,0x1C}, {0x3C,0x40,0x30,0x40,0x3C},
	{0x44,0x28,0x10,0x28,0x44}, {0x1C,0xA0,0xA0,0xA0,0x7C}, {0x44,0x64,0x54,0x4C,0x44}, {0x00,0x08,0x36,0x41,0x00},
	{0x00,0x00,0x7F,0x00,0x00}, {0x00,0x41,0x36,0x08,0x00}, {0x10,0x08,0x08,0x10,0x08},
};

void gfx_clear(void) {
	memset(fb, 0, sizeof(fb));
}

void gfx_pixel(int x, int y, uint8_t on) {
	if (x < 0 || x >= GFX_W || y < 0 || y >= GFX_H) {
		return;
	}
	if (on) {
		fb[y >> 3][x] |= (uint8_t)(1U << (y & 7));
	}
	else {
		fb[y >> 3][x] &= (uint8_t)~(1U << (y & 7));
	}
}

uint8_t gfx_get(int x, int y) {
	if (x < 0 || x >= GFX_W || y < 0 || y >= GFX_H) {
		return 0;
	}
	return (fb[y >> 3][x] >> (y & 7)) & 1U;
}

void gfx_fill(int x, int y, int w, int h, uint8_t on) {
	for (int j = y; j < y + h; j++) {
		for (int i = x; i < x + w; i++) {
			gfx_pixel(i, j, on);
		}
	}
}

void gfx_hline(int x, int y, int w, uint8_t on) {
	gfx_fill(x, y, w, 1, on);
}

void gfx_vline(int x, int y, int h, uint8_t on) {
	gfx_fill(x, y, 1, h, on);
}

void gfx_rect(int x, int y, int w, int h, uint8_t on) {
	gfx_hline(x, y, w, on);
	gfx_hline(x, y + h - 1, w, on);
	gfx_vline(x, y, h, on);
	gfx_vline(x + w - 1, y, h, on);
}

void gfx_invert(int x, int y, int w, int h) {
	for (int j = y; j < y + h; j++) {
		for (int i = x; i < x + w; i++) {
			gfx_pixel(i, j, !gfx_get(i, j));
		}
	}
}

int gfx_text(int x, int y, const char* s, uint8_t scale) {
	for (; *s; s++, x += GFX_FONT_W * scale) {
		uint8_t ch = (uint8_t)*s;
		const uint8_t* g;

		if (ch < 0x20 || ch > 0x7E) {
			ch = '?';
		}
		g = font5x7[ch - 0x20];
		for (int col = 0; col < 5; col++) {
			for (int row = 0; row < 8; row++) {
				if (g[col] & (1U << row)) {
					if (scale == 1) {
						gfx_pixel(x + col, y + row, 1);
					}
					else {
						gfx_fill(x + col * scale, y + row * scale, scale, scale, 1);
					}
				}
			}
		}
	}
	return x;
}

int gfx_text_width(const char* s, uint8_t scale) {
	int n = (int)strlen(s);

	return n ? (n * GFX_FONT_W - 1) * scale : 0;
}

int gfx_text_center(int y, const char* s, uint8_t scale) {
	return gfx_text((GFX_W - gfx_text_width(s, scale)) / 2, y, s, scale);
}

/*      a
 *    f   b
 *      g
 *    e   c
 *      d       bit 0 = a ... bit 6 = g */
void gfx_digit7(int x, int y, int w, int h, int t, uint8_t digit) {
	static const uint8_t seg[10] = { 0x3F, 0x06, 0x5B, 0x4F, 0x66, 0x6D, 0x7D, 0x07, 0x7F, 0x6F };
	uint8_t s = seg[digit % 10];
	int half = (h - t) / 2;

	if (s & 0x01) gfx_fill(x + 1, y, w - 2, t, 1);
	if (s & 0x02) gfx_fill(x + w - t, y + 1, t, half - 1 + t / 2, 1);
	if (s & 0x04) gfx_fill(x + w - t, y + half + t / 2, t, h - half - t / 2 - 1, 1);
	if (s & 0x08) gfx_fill(x + 1, y + h - t, w - 2, t, 1);
	if (s & 0x10) gfx_fill(x, y + half + t / 2, t, h - half - t / 2 - 1, 1);
	if (s & 0x20) gfx_fill(x, y + 1, t, half - 1 + t / 2, 1);
	if (s & 0x40) gfx_fill(x + 1, y + half, w - 2, t, 1);
}

char* gfx_utoa(char* buf, uint32_t v, uint8_t min_digits) {
	char tmp[11];
	uint8_t n = 0;
	char* p = buf;

	do {
		tmp[n++] = (char)('0' + v % 10);
		v /= 10;
	} while (v);
	while (n < min_digits && n < sizeof(tmp)) {
		tmp[n++] = '0';
	}
	while (n) {
		*p++ = tmp[--n];
	}
	*p = 0;
	return buf;
}

uint8_t gfx_flush(uint8_t force) {
	uint8_t written = 0;

	for (uint8_t p = 0; p < KIT_LCD_PAGES; p++) {
		if (force || memcmp(fb[p], shown[p], GFX_W) != 0) {
			if (kit_lcd_write_page(p, fb[p])) {
				memcpy(shown[p], fb[p], GFX_W);
			}
			written++;
		}
	}
	return written;
}

const uint8_t* gfx_page(uint8_t page) {
	return fb[page % KIT_LCD_PAGES];
}
